# Keil uVision project Projet_TP4.uvproj, settings and files
target Simulation (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: TP4_IRC_Sim
  c flags: Optimize=8 SizeSpeed=1
  group Programmes Source 1
    ./: STARTUP.A51 Lib_Base.c Asm_8051_Lib.asm Lib_TP4.C Main_TP4.C
target Exécution 8051FX20-TB (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: TP4_IRC
  c flags: Optimize=8 SizeSpeed=1
